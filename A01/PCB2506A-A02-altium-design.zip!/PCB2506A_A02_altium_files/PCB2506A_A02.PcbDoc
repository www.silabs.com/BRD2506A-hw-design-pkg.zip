# Altium PCB PCB2506A_A02.PcbDoc (part 3 of 7)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 115 x 60 mm, 6 copper layers (Top Layer, Signal Layer 2, Signal Layer 3, Signal Layer 4, Signal Layer 5, Bottom Layer), stack 1.555 mm thick; 377 components, 291 nets, 1299 pads, 899 vias.

## Via types
v1: diameter 0.508, hole 0.25, Top Layer to Bottom Layer, tented both sides, 899 vias

## Nets (pads, with @x,y where several pads share a name; then routed paths per layer and width w, separated by ;. In a path a pad name is that pad's centre, name@x,y a point inside that pad or via, vN(x,y) a via of type N, cw(c..) or ccw(c..) an arc to the next point about the centre after c; other vN are vias at no path point) (continued)
BREAKOUT_BOT8: J101.8 P101.7 R323.2 | length 79.4
  Top Layer w0.1: J101.8@48.73,3.262 48.73,5.73 R323.2@48.75,5.75 49.336,5.75 v1(50.089,6.502) ; v1(106.68,24.994) 107.876,26.19 P101.7@108.76,26.19
  Signal Layer 4 w0.1: v1(50.089,6.502) 50.14,6.452 56.21,6.452 57.263,7.505 74.612,7.505 76.581,9.474 76.581,11.376 75.12,12.837 75.12,19.643 79.074,23.597 80.213,23.597 80.594,23.216 88.062,23.216 89.179,24.333 100.745,24.333 101.405,24.994 v1(106.68,24.994)
BREAKOUT_BOT9: J101.9 R317.2 | length 2.6
  Top Layer w0.1: J101.9@51.25,3.162 J101.9@51.3,3.212 ; J101.9@51.27,3.262 51.27,5.72 R317.2@51.3,5.75
BREAKOUT_BOT10: J101.10 P101.9 R305.1 U1.29 | length 101.3
  Top Layer w0.1: J101.10@53.81,3.262 53.8,3.272 R305.1@53.8,5.75 53.85,5.7 v1(55.075,5.7) ; U1.29@86.8,28.85 86.8,28.525 88.036,27.289 88.036,26.264 v1(88.061,26.24) ; v1(106.604,27.508) 107.826,28.73 P101.9@108.76,28.73
  Signal Layer 3 w0.1: v1(101.016,20.726) 101.346,20.396 103.149,20.396 105.588,22.835 105.588,26.492 v1(106.604,27.508)
  Signal Layer 4 w0.1: v1(55.075,5.7) 57.948,5.7 58.606,6.358 74.709,6.358 77.445,9.093 77.445,11.506 75.794,13.157 75.794,19.177 78.156,21.539 100.203,21.539 v1(101.016,20.726) ; v1@88.005,26.184 v1(88.061,26.24) ; v1@88.06,26.264 88.334,26.537 98.812,26.537 99.664,25.685 102.139,25.685 103.962,27.508 v1(106.604,27.508)
BREAKOUT_BOT11: J101.11 P101.5 R322.2 | length 73.1
  Top Layer w0.1: J101.11@56.35,3.262 R322.2@56.35,5.75 57.464,5.75 57.709,5.994 v1(57.709,6.934) ; v1(106.68,22.53) 107.8,23.65 P101.5@108.76,23.65
  Signal Layer 4 w0.1: v1(57.709,6.934) 57.988,7.214 74.727,7.214 76.857,9.344 76.857,11.383 75.32,12.92 75.32,19.541 79.175,23.397 79.97,23.397 80.431,22.936 88.13,22.936 89.197,24.003 101.092,24.003 101.676,24.587 104.623,24.587 v1(106.68,22.53)
BREAKOUT_BOT12: J101.12
BREAKOUT_BOT13: C8.1 J101.13 Q800.6 SW1.1 SW1.2 TP400.1 U1.21 | length 95.3
  Top Layer w0.1: Q800.6@67.033,35.8 67.033,35.738 67.374,35.397 v1(68.174,35.397) ; v1(83.582,27.143) 83.504,27.221 83.504,27.401 83.499,27.405 83.499,28.254 83.6,28.355 U1.21@83.6,28.85 ; v1@83.591,27.153 83.591,27.023 83.69,26.924 83.69,26.798 C8.1@83.8,26.688 ; v1(97.612,32.741) 97.612,33.426 97.925,33.739 SW1.1@97.925,35.625 SW1.2@97.925,39.775
  Signal Layer 3 w0.1: J101.13@61.43,3.262 61.43,15.906 v1(62.332,16.808) ; v1(71.694,18.809) 71.694,23.332 74.905,26.543 74.905,34.508 v1(75.362,34.966)
  Signal Layer 4 w0.1: v1(62.332,16.808) 69.693,16.808 v1(71.694,18.809) 78.641,25.756 80.137,25.756 80.504,25.388 82.995,25.388 83.582,25.975 v1(83.582,27.143) 83.617,27.178 85.05,27.178 85.203,27.331 85.218,27.331 85.852,27.965 87.63,27.965 87.732,27.864 90.968,27.864 92.964,29.86 92.964,30.781 94.136,31.953 95.007,31.953 95.794,32.741 v1(97.612,32.741) ; v1(68.174,35.397) 69.407,35.397 69.879,34.925 74.562,34.925 74.667,35.03 75.298,35.03 v1(75.362,34.966)
  Bottom Layer w0.1: TP400.1@82.175,28.4 82.325,28.4 v1(83.582,27.143)
BREAKOUT_TOP3: J102.3 P101.6 U1.61 | length 140.2
  Top Layer w0.1: v1(77.382,38.755) 77.933,38.755 78.126,38.562 83.681,38.562 85.112,37.13 85.118,37.13 85.2,37.048 U1.61@85.2,36.75 ; v1(101.727,23.724) 104.496,23.724 P101.6@104.57,23.65
  Signal Layer 3 w0.1: v1(77.382,38.755) 77.382,38.644 77.521,38.505 77.521,31.598 78.283,30.836 78.283,24.384 v1(79.68,22.987) ; v1(94.513,47.269) 94.894,46.888 94.894,46.514 100.138,41.27 100.138,39.243 102.01,37.372 102.01,24.656 101.727,24.374 v1(101.727,23.724)
  Signal Layer 4 w0.1: J102.3@36.03,56.602 40.382,52.25 67.333,52.25 72.015,47.568 78.073,47.568 78.237,47.732 89.022,47.732 89.295,47.459 91.631,47.459 91.784,47.307 94.476,47.307 v1(94.513,47.269) ; v1(79.68,22.987) 79.75,22.987 80,22.736 100.74,22.736 v1(101.727,23.724)
BREAKOUT_TOP4: J102.4 P101.4 U1.62 | length 142
  Top Layer w0.1: v1(76.246,37.694) 76.914,38.362 83.562,38.362 84.75,37.173 84.75,37.152 84.8,37.102 U1.62@84.8,36.75 ; v1(102.21,21.094) 102.218,21.086 104.546,21.086 P101.4@104.57,21.11
  Signal Layer 3 w0.1: v1(76.246,37.694) 76.246,34.247 77.292,33.201 77.292,30.683 78.029,29.947 78.029,23.495 v1(79.197,22.327) ; v1(95.072,47.549) 95.148,47.473 95.148,46.543 100.338,41.353 100.338,39.326 102.21,37.455 v1(102.21,21.094)
  Signal Layer 4 w0.1: J102.4@38.57,56.602 42.722,52.45 67.416,52.45 72.098,47.768 77.943,47.768 78.107,47.932 89.126,47.932 89.396,47.662 94.676,47.662 94.712,47.627 94.994,47.627 v1(95.072,47.549) ; v1(79.197,22.327) 100.965,22.327 102.198,21.094 v1(102.21,21.094)
BREAKOUT_TOP5: J102.5 P101.15 U1.63 U103.9 | length 134
  Top Layer w0.1: v1(78.87,37.081) 78.912,37.122 78.912,37.769 79.305,38.162 83.479,38.162 84.4,37.241 U1.63@84.4,36.75 ; U103.9@104.788,51.136 104.788,51.769 105.422,52.403 105.422,52.503 105.689,52.77 v1(105.689,52.807) ; v1(108.433,37.465) 108.433,36.677 P101.15@108.76,36.35
  Signal Layer 3 w0.1: v1(105.689,52.807) 105.757,52.739 106.98,52.739 107.975,51.743 107.975,49.987 107.493,49.505 107.493,46.711 109.711,44.492 109.711,42.714 110.388,42.037 110.388,39.421 v1(108.433,37.465)
  Signal Layer 4 w0.1: J102.5@41.11,56.602 45.062,52.65 67.499,52.65 72.181,47.968 77.687,47.968 77.954,48.235 89.154,48.235 89.446,47.943 98.327,47.943 99.152,48.768 100.627,48.768 102.328,50.47 102.899,50.47 103.226,50.797 103.226,52.146 103.838,52.759 104.442,52.759 104.634,52.566 105.359,52.566 105.599,52.807 v1(105.689,52.807) ; v1(78.87,37.081) 78.853,37.098 78.853,38.746 79.423,39.316 79.5,39.316 79.531,39.348 79.857,39.348 79.864,39.34 79.947,39.34 80.217,39.61 80.608,39.61 81.388,38.83 83.859,38.83 84.074,38.615 85.44,38.615 85.914,39.089 86.464,39.089 87.045,38.508 102.234,38.508 102.638,38.103 107.794,38.103 v1(108.433,37.465)
BREAKOUT_TOP6: J102.6 P101.16 U1.64 U103.10 | length 126.7
  Top Layer w0.1: v1(79.654,37.719) 79.667,37.732 80.058,37.732 80.288,37.962 83.349,37.962 84,37.31 U1.64@84,36.75 ; v1(102.641,36.297) 104.517,36.297 P101.16@104.57,36.35 ; U103.10@104.388,51.136 104.388,51.813 105.029,52.454 105.029,52.562 105.005,52.585 105.005,52.881 v1(104.927,52.959)
  Signal Layer 3 w0.1: v1(102.641,36.297) 106.553,36.297 110.188,39.932 110.188,41.881 109.511,42.559 109.511,44.409 107.29,46.631 107.29,49.584 107.772,50.067 107.772,51.664 107.163,52.273 105.613,52.273 v1(104.927,52.959)
  Signal Layer 4 w0.1: J102.6@43.65,56.602 47.402,52.85 67.582,52.85 72.264,48.168 77.604,48.168 77.871,48.435 89.237,48.435 89.525,48.147 98.248,48.147 99.177,49.076 100.652,49.076 102.246,50.67 102.816,50.67 102.993,50.847 102.993,52.345 103.607,52.959 v1(104.927,52.959) ; v1(79.654,37.719) 80.069,38.134 83.706,38.134 83.938,37.903 98.695,37.903 99.18,37.417 100.067,37.417 101.188,36.297 v1(102.641,36.297)
BREAKOUT_TOP7: J102.7 P101.14 U1.65 U812.4 | length 123.4
  Top Layer w0.1: U812.4@63.795,28.38 64.05,28.125 64.516,28.125 v1(64.908,28.517) ; v1(80.44,37.558) 80.499,37.558 80.703,37.762 83.193,37.762 83.6,37.355 U1.65@83.6,36.75 ; v1(100.736,32.817) 100.736,32.842 101.704,33.81 P101.14@104.57,33.81
  Signal Layer 3 w0.1: v1(92.304,48.539) 99.593,41.25 99.593,37.891 101.078,36.407 101.078,33.158 v1(100.736,32.817)
  Signal Layer 4 w0.1: J102.7@46.19,56.602 49.135,53.657 55.767,53.657 56.137,53.286 67.711,53.286 72.237,48.761 75.209,48.761 75.496,49.047 77.271,49.047 77.387,48.932 79.516,48.932 79.79,48.658 91.338,48.658 91.457,48.539 v1(92.304,48.539) ; v1(64.908,28.517) 64.96,28.517 65.279,28.836 67.477,28.836 67.787,29.146 67.787,29.637 68.523,30.372 70.305,30.372 70.683,29.994 73.962,29.994 75.717,31.75 75.717,33.056 76.24,33.578 77.157,33.578 77.524,33.945 77.524,36.176 78.035,36.688 79.153,36.688 79.567,37.102 79.984,37.102 v1(80.44,37.558) 80.44,37.666 80.708,37.934 83.623,37.934 83.855,37.703 88.38,37.703 90.036,36.048 97.506,36.048 v1(100.736,32.817)
BREAKOUT_TOP8: J102.8 P101.12 U1.66 U812.2 | length 122.5
  Top Layer w0.1: v1(62.984,28.077) 62.992,28.085 62.992,28.607 U812.2@63,28.615 ; v1(81.153,37.338) 81.616,37.338 81.84,37.562 82.936,37.562 83.2,37.298 U1.66@83.2,36.75 ; v1(100.925,32.066) 100.925,32.044 101.699,31.27 P101.12@104.57,31.27
  Signal Layer 3 w0.1: v1(93.167,48.692) 94.121,47.738 94.121,47.005 99.847,41.278 99.847,37.92 101.278,36.489 101.278,32.469 100.925,32.117 v1(100.925,32.066)
  Signal Layer 4 w0.1: J102.8@48.73,56.602 51.369,53.963 55.866,53.963 56.337,53.492 61.697,53.492 62.276,54.072 63.171,54.072 63.711,53.532 67.768,53.532 72.339,48.961 75.126,48.961 75.416,49.251 77.351,49.251 77.469,49.132 79.598,49.132 79.873,48.858 91.711,48.858 91.875,49.022 92.837,49.022 v1(93.167,48.692) ; v1(62.984,28.077) 63.414,28.077 63.766,27.724 65.367,27.724 65.879,28.236 67.996,28.236 69.345,29.586 70.305,29.586 70.514,29.794 74.241,29.794 76.886,32.439 76.886,32.995 77.724,33.833 77.724,36.093 78.105,36.474 79.223,36.474 79.577,36.828 80.106,36.828 80.371,36.564 80.732,36.564 81.014,36.847 81.014,37.089 81.153,37.228 v1(81.153,37.338) 81.612,37.338 81.836,37.562 83.713,37.562 83.772,37.503 88.176,37.503 89.832,35.848 97.121,35.848 100.903,32.066 v1(100.925,32.066)
BREAKOUT_TOP9: J102.9 R324.1 U1.67 | length 50
  Top Layer w0.1: R324.1@51,54.35 51,54.355 51.27,54.625 J102.9@51.27,56.602 ; v1(81.407,36.779) 81.953,37.325 82.69,37.325 82.793,37.222 82.793,36.757 U1.67@82.8,36.75
  Signal Layer 3 w0.1: v1(74.704,50.495) 74.704,50.442 75.108,50.038 77.06,50.038 81.148,45.951 81.148,39.812 80.939,39.604 80.939,38.425 81.585,37.78 81.585,37.042 81.407,36.864 v1(81.407,36.779)
  Bottom Layer w0.1: J102.9@51.27,56.602 52.883,54.989 52.883,53.635 55.443,51.075 70.54,51.075 72.09,49.525 73.731,49.525 v1(74.704,50.495) v1(74.704,50.495)
BREAKOUT_TOP10: J102.10 R985.1 U1.48 U103.6 U103.12 U103.13 | length 79.1
  Top Layer w0.1: U1.48@89.55,34.8 90.361,34.8 90.451,34.71 91.113,34.71 91.43,35.027 92.154,35.027 v1(92.178,35.05) ; v1(101.727,50.749) 102.025,50.451 U103.13@103.538,50.451 ; R985.1@103.353,52.298 103.387,52.264 103.387,51.959 103.588,51.759 U103.12@103.588,51.136 103.588,50.501 U103.13@103.538,50.451 ; U103.6@105.385,50.001 105.335,50.051 105.033,50.051 104.897,50.186 104.427,50.186 104.163,50.451 103.588,50.451 U103.13@103.538,50.451
  Signal Layer 3 w0.1: v1(87.605,49.251) 88.467,49.251 90.653,47.065 90.653,46.057 91.719,44.99 91.719,36.295 92.178,35.836 v1(92.178,35.05)
  Signal Layer 4 w0.1: J102.10@53.81,56.602 53.81,56.367 56.481,53.696 61.617,53.696 62.201,54.28 63.246,54.28 63.779,53.746 67.837,53.746 72.422,49.161 75.043,49.161 75.362,49.479 77.521,49.479 77.668,49.332 79.681,49.332 79.944,49.07 86.926,49.07 87.107,49.251 v1(87.605,49.251) 89.23,49.251 89.423,49.058 91.628,49.058 91.985,49.415 95.67,49.415 96.645,48.44 98.199,48.44 99.035,49.276 100.569,49.276 101.503,50.21 101.503,50.487 101.727,50.711 v1(101.727,50.749)
BREAKOUT_TOP11: J102.11 R300.1 U1.39 | length 61.3
  Top Layer w0.1: R300.1@56.35,54.2 J102.11@56.35,56.602 ; R300.1@56.4,54.15 56.479,54.229 v1(57.658,54.229) ; U1.39@89.364,31.2 89.369,31.205 91.352,31.205 v1(91.364,31.217)
  Signal Layer 3 w0.1: v1(90.272,49.451) 90.331,49.451 93.049,46.733 93.049,34.55 92.376,33.876 92.376,33.551 92.532,33.394 92.532,32.385 v1(91.364,31.217)
  Signal Layer 4 w0.1: v1(57.658,54.229) 60.539,54.229 60.793,54.483 67.383,54.483 72.475,49.39 74.957,49.39 75.301,49.734 79.577,49.734 80.042,49.27 86.843,49.27 87.217,49.643 89.405,49.643 89.545,49.504 90.218,49.504 v1(90.272,49.451)
BREAKOUT_TOP12: J102.12 U1.38 U805.1 | length 71.8
  Top Layer w0.1: v1(62.395,35.737) 62.439,35.737 62.6,35.898 U805.1@62.6,36.115 ; U1.38@89.498,30.748 91.718,30.748 91.975,31.006 91.975,31.063 v1(91.972,31.063)
  Signal Layer 3 w0.1: J102.12@58.89,56.602 58.918,56.602 61.319,54.201 61.319,47.323 60.88,46.885 60.88,41.424 61.036,41.267 61.036,40.766 61.64,40.162 61.669,40.162 62.032,39.799 62.032,38.823 62.032,38.645 62.032,37.94 62.814,37.157 62.814,36.157 v1(62.395,35.737) ; v1(91.972,31.063) 91.975,31.063 92.054,31.063 92.3,31.309 92.371,31.309 93.29,32.228 93.29,33.952 93.45,34.112 93.45,39.769 v1(93.8,40.12)
  Signal Layer 4 w0.1: v1@61.484,39.986 61.646,40.147 v1(61.655,40.147) ; v1@62.396,35.735 63.051,36.39 69.131,36.39 69.737,36.996 71.437,36.996 72.888,35.545 73.981,35.545 74.29,35.853 76.493,35.853 77.419,36.779 77.419,37.888 79.279,39.748 79.788,39.748 80.437,40.396 82.337,40.396 82.804,39.929 93.499,39.929 93.69,40.12 v1(93.8,40.12)
BREAKOUT_TOP13: J102.13 U1.37 U805.3 | length 76.6
  Top Layer w0.1: v1(63.067,35.184) 63.067,35.228 63.4,35.562 U805.3@63.4,36.115 ; U1.37@89.346,30.4 90.22,30.4 90.236,30.416 90.866,30.416 90.986,30.295 91.665,30.295 v1(91.696,30.326)
  Signal Layer 3 w0.1: J102.13@61.43,56.602 61.519,56.513 61.519,47.194 61.08,46.755 61.08,41.506 61.825,40.761 v1(61.825,40.731) ; v1@61.841,40.745 61.944,40.642 61.944,40.418 62.232,40.13 62.232,38.906 ; 62.232,38.905 62.232,38.149 63.043,37.338 63.043,35.208 v1(63.067,35.184) ; v1(91.696,30.326) 91.794,30.326 93.49,32.022 93.49,33.869 93.65,34.029 93.65,39.37 95.326,41.046 v1(95.326,41.072)
  Signal Layer 4 w0.1: v1(61.825,40.731) 61.825,40.651 62.032,40.444 62.032,40.411 63.284,39.159 63.284,38.432 63.94,37.776 66.275,37.776 66.714,37.337 67.331,37.337 67.722,37.728 67.722,37.746 68.113,38.137 69.399,38.137 69.402,38.134 70.592,38.134 70.858,38.4 73.198,38.4 75.564,40.766 79.322,40.766 79.561,41.005 79.561,41.01 79.998,41.446 80.002,41.446 86.557,41.446 87.789,42.678 90.964,42.678 92.28,41.362 95.036,41.362 v1(95.326,41.072)
BREAKOUT_TOP14: J102.14
DAC_LC_EXCITE: R121.1 R322.1 U1.30 | length 53.3
  Top Layer w0.1: v1(56.337,7.569) 56.337,6.663 R322.1@56.35,6.65 ; v1(75.717,11.684) 75.717,11.183 R121.1@75.75,11.15 ; U1.30@87.2,28.85 87.2,28.525 88.748,26.977 v1(88.748,26.144)
  Signal Layer 4 w0.1: v1(56.337,7.569) 56.871,7.569 57.125,7.823 74.524,7.823 76.327,9.627 76.327,11.074 v1(75.717,11.684) 74.727,12.675 74.727,19.533 79.019,23.825 87.017,23.825 88.748,25.556 v1(88.748,26.144)
DBG_VREGO: C902.1 U900.A12 | length 2.4
  Top Layer w0.1: C902.1@44.45,36.875 44.5,36.825 C902.1@44.525,36.825
  Top Layer w0.2: 45.692,38.183 45.727,38.148 46,38.421 U900.A12@46,38.5
  Top Layer w0.3: C902.1@44.55,36.875 44.95,37.275 44.95,37.441 45.692,38.183
DEBUG_#RESET_IN: U808.7 U900.N5 | length 15.8
  Top Layer w0.1: U900.N5@49.5,44.5 49.925,44.925 50.263,44.925 50.61,45.273 50.61,46.56 50.904,46.854 51.248,46.854 v1(51.308,46.914) ; v1(57.696,42.913) 59.084,42.913 U808.7@59.097,42.901
  Bottom Layer w0.1: v1(51.308,46.914) 51.642,47.247 56.664,47.247 58.344,45.568 58.344,43.561 v1(57.696,42.913)
DEBUG_DH_SW_ENABLE: R900.1 U803.1 U900.F1 | length 60.6
  Top Layer w0.1: U900.F1@51.5,41 51.95,41 51.975,40.975 v1(52.425,40.975) ; U803.1@57.521,35.599 57.771,35.599 57.846,35.674 57.846,36.016 v1(57.893,36.063) ; v1(86.7,54.35) 86.95,54.1 R900.1@87.25,54.1
  Signal Layer 3 w0.1: v1(57.637,40.757) 58.082,40.312 58.082,36.94 57.893,36.751 v1(57.893,36.063) ; v1(71.78,54.686) 71.275,54.181 71.275,53.722 72.375,52.622 72.375,49.583 71.847,49.055 71.847,43.857 71.644,43.653 71.644,41.507 71.811,41.34 v1(71.811,39.4)
  Signal Layer 4 w0.1: v1(52.425,40.975) 52.425,41.131 53.169,41.875 54.175,41.875 55.47,40.581 56.532,40.581 56.709,40.757 v1(57.637,40.757) ; v1(71.78,54.686) 86.314,54.686 v1@86.65,54.35
  Bottom Layer w0.1: v1(57.637,40.757) 58.914,40.757 59.336,40.335 60.477,40.335 61.266,41.124 63.118,41.124 65.01,39.231 67.676,39.231 68.043,39.599 71.548,39.599 71.747,39.4 v1(71.811,39.4)
DEBUG_MCU_SW_ENABLE: R814.2 R815.2 U803.7 U805.5 U805.6 U805.12 U805.13 U900.G1 | length 33.8
  Top Layer w0.1: v1(49.525,42.35) 49.525,42.4 49.844,42.719 50.274,42.719 50.306,42.75 51.125,42.75 51.25,42.625 51.25,41.75 U900.G1@51.5,41.5 ; v1(59.957,35.243) 60.029,35.171 60.549,35.171 U803.7@60.621,35.099 ; v1(60.739,39.689) 60.835,39.689 60.835,39.652 61.351,39.652 62.6,38.403 62.6,37.25 62.55,37.2 U805.13@62.515,37.2 ; U805.5@64.2,36.115 64.2,36.75 U805.6@64.25,36.8 ; U805.6@64.285,36.8 64.525,36.8 64.606,36.881 64.711,36.881 64.735,36.905 64.895,36.905 v1(64.973,36.983) ; R814.2@65.232,36.4 65.122,36.51 65.122,36.724 64.973,36.873 64.973,36.974 64.983,36.974 65.232,37.222 R815.2@65.232,37.232
  Signal Layer 3 w0.1: v1(59.957,35.243) 59.957,35.706 60.223,35.973 60.223,36.966 60.739,37.482 v1(60.739,39.689)
  Signal Layer 4 w0.1: v1(49.525,42.35) 49.525,41.669 50.612,40.582 52.718,40.582 53.075,40.225 53.55,40.225 54.025,40.7 54.943,40.7 55.334,40.31 56.221,40.31 56.908,39.623 58.98,39.623 59.046,39.689 v1(60.739,39.689) ; v1(59.957,35.243) 60.601,35.886 60.821,35.886 61.918,36.983 v1(64.973,36.983)
DEBUG_RESET_#OE: U804.1 U900.D1 | length 7.8
  Top Layer w0.1: U900.D1@51.5,40 51.846,40 51.944,39.902 v1(52.054,39.902) ; U804.1@52.053,34.954 52.128,34.879 52.165,34.916 52.808,34.916 v1(53.196,34.527)
  Signal Layer 3 w0.1: v1(52.054,39.902) 53.222,38.734 53.222,34.553 v1(53.196,34.527)
DEBUG_TCK_SWCLK_#OE: U809.1 U900.B1 | length 5.8
  Top Layer w0.1: U900.B1@51.5,39 51.519,38.981 51.726,38.981 51.811,38.896 v1(51.921,38.896) ; v1(55.081,37.033) 55.105,37.009 56.474,37.009 U809.1@56.498,36.985
  Signal Layer 4 w0.1: v1(51.921,38.896) 52.341,38.896 54.204,37.033 v1(55.081,37.033)
DEBUG_TCK_SWCLK_IN: U808.4 U900.N3 | length 9.6
  Top Layer w0.1: U900.N3@50.5,44.5 50.845,44.845 51.198,44.845 52.304,45.95 53.062,45.95 53.264,46.152 55.015,46.152 55.242,45.925 56.059,45.925 56.134,45.85 56.385,45.85 56.852,45.85 57.14,45.562 57.14,45.374 57.419,45.095 57.667,45.095 57.927,44.835 58.79,44.835 U808.4@58.8,44.825
DEBUG_TCK_SWCLK_OUT: U809.2 U900.C1 | length 5.9
  Top Layer w0.1: U900.C1@51.5,39.5 53.345,39.5 53.522,39.322 v1(53.633,39.322) ; v1(54.484,38.38) 55.379,37.485 U809.2@56.498,37.485
  Signal Layer 4 w0.1: v1(53.633,39.322) 54.484,38.471 v1(54.484,38.38)
DEBUG_TDI_#OE: U809.7 U900.E1 | length 6.3
  Top Layer w0.1: U900.E1@51.5,40.5 52.012,40.5 52.445,40.067 52.445,39.943 52.673,39.715 53.83,39.715 54.026,39.519 54.026,39.04 53.746,38.76 52.961,38.76 52.873,38.672 52.873,37.798 53.073,37.598 53.073,37.56 53.148,37.485 U809.7@53.398,37.485
DEBUG_TDI_C2DPS: U805.11
DEBUG_TDI_IN: U808.6 U900.N4 | length 11.6
  Top Layer w0.1: U900.N4@50,44.5 50.027,44.5 50.188,44.661 50.307,44.661 50.758,45.111 50.767,45.111 50.893,45.237 v1(51.003,45.237) ; v1(57.531,43.699) 57.559,43.671 58.662,43.671 U808.6@58.793,43.54
  Bottom Layer w0.1: v1(51.003,45.237) 51.483,44.757 51.483,44.503 51.885,44.101 52.255,44.101 52.625,44.471 53.666,44.471 54.966,45.771 55.648,45.771 55.769,45.65 56.001,45.65 57.531,44.12 v1@57.531,43.699
DEBUG_TDI_OUT: U809.5 U900.E2 | length 5.6
  Top Layer w0.1: U900.E2@51,40.5 51.25,40.75 52.045,40.75 52.645,40.15 52.645,40.026 52.756,39.915 53.913,39.915 54.26,39.568 54.26,38.943 53.856,38.539 53.452,38.539 U809.5@53.398,38.485
DEBUG_TDO_SWO: R300.2 U805.8 | length 24.9
  Top Layer w0.1: R300.2@56.4,53.25 62.309,53.25 v1(62.738,53.679) ; v1(62.425,40.574) 63.03,39.969 63.03,39.695 63.564,39.161 63.666,39.161 64.2,38.627 U805.8@64.2,37.737
  Signal Layer 3 w0.1: v1(62.425,40.574) 62.389,40.61 62.389,40.91 62.23,41.069 62.23,41.072 61.28,42.022 61.28,46.595 62.31,47.625 63.41,48.725 63.41,53.006 v1(62.738,53.679)
DEBUG_TDO_SWO_IN: U808.5 U900.E3 | length 15.6
  Top Layer w0.1: v1(48.25,42.35) 48.65,41.95 48.82,41.95 49.838,40.932 50.175,40.932 50.5,40.607 U900.E3@50.5,40.5 ; v1(57.504,44.702) 57.573,44.633 57.817,44.633 58.254,44.196 U808.5@58.471,44.196
  Signal Layer 3 w0.1: v1(48.25,42.35) v1@48.331,42.35
  Signal Layer 4 w0.1: v1(48.25,42.35) 48.025,42.575 48.025,43.225 48.625,43.825 51.979,43.825 53.039,44.885 55.552,44.885 55.562,44.895 56.089,44.895 56.617,44.895 56.81,44.702 v1(57.504,44.702)
DEBUG_TMS_SWDIO_#OE: U804.7 U900.D2 | length 13.9
  Top Layer w0.1: U804.7@48.953,35.454 49.203,35.454 49.478,35.179 49.478,34.415 49.295,34.232 49.295,33.469 49.842,32.921 51.46,32.921 52.432,33.893 v1(52.432,33.898) ; U900.D2@51,40 51.25,39.75 51.25,39.388 51.388,39.25 51.72,39.25 51.759,39.289 52.304,39.289 52.673,38.92 52.673,37.915 52.58,37.822 52.58,37.66 v1(52.502,37.582)
  Signal Layer 3 w0.1: v1(52.432,33.898) 52.374,33.955 52.374,34.313 52.324,34.363 52.324,35.741 52.229,35.836 52.229,36.959 52.448,37.178 52.448,37.528 v1(52.502,37.582)
DEBUG_TMS_SWDIO_IN: U808.3 U900.M3 | length 9.2
  Top Layer w0.1: U900.M3@50.5,44 50.75,44.25 51.604,44.25 51.704,44.35 51.838,44.35 51.982,44.494 v1(52.092,44.494) ; v1(57.691,45.487) U808.3@58.265,45.487 ; U808.3@58.265,45.488 58.389,45.364 U808.3@58.616,45.364
  Bottom Layer w0.1: v1(52.092,44.494) 52.17,44.572 52.358,44.572 52.612,44.825 53.69,44.825 54.835,45.971 55.731,45.971 55.852,45.85 56.182,45.85 56.544,45.488 v1@57.69,45.488
DEBUG_TMS_SWDIO_OUT: U804.5 U900.C2 | length 6.6
  Top Layer w0.1: U804.5@48.953,36.454 49.022,36.523 49.272,36.523 49.318,36.568 49.432,36.568 v1(49.51,36.646) ; v1@50.1,40.45 50.3,40.25 50.675,40.25 50.75,40.175 50.75,39.75 U900.C2@51,39.5
  Signal Layer 3 w0.1: v1(49.51,36.646) 49.575,36.646 50.368,37.44 50.368,40.161 v1(50.002,40.527)
DEBUG_TRACECLK: D801.2 P800.12 | length 3.2
  Top Layer w0.1: D801.2@75.95,52.215 75.95,52.35 76.275,52.675 77.325,52.675 77.865,53.215 P800.12@77.865,54.05
DEBUG_TRACED0: D801.3 P800.14 | length 2.5
  Top Layer w0.1: D801.3@75.45,52.215 75.45,52.375 75.95,52.875 76.225,52.875 76.595,53.245 P800.14@76.595,54.05
DEBUG_TRACED1: D801.4 P800.16 | length 2
  Top Layer w0.1: D801.4@74.95,52.215 74.95,52.75 75.325,53.125 P800.16@75.325,54.05
DEBUG_TRACED2: D801.5 P800.18 | length 3.6
  Top Layer w0.1: P800.18@74.055,54.05 74.055,52.47 74.171,52.354 74.171,51.599 74.401,51.369 75.184,51.369 D801.5@75.2,51.385
DEBUG_TRACED3: D801.6 P800.20 | length 5.3
  Top Layer w0.1: P800.20@72.785,54.05 72.785,53.215 73.971,52.029 73.971,51.516 74.562,50.925 75.4,50.925 75.7,51.225 D801.6@75.7,51.385
DH_#RESET: D800.4 P800.10 R816.1 TPJ811.1 U802.3 | length 32.1
  Top Layer w0.1: R816.1@67.748,38.447 67.944,38.642 68.23,38.642 68.55,38.962 68.55,39 68.7,39.15 U802.3@69.175,39.15 69.24,39.085 v1(70.688,39.085) ; P800.10@79.135,54.05 79.135,53.24 79.725,52.65 80.425,52.65 80.65,52.425 D800.4@80.65,52.215 80.585,52.15 79.85,52.15 v1(79.85,52.193)
  Signal Layer 3 w0.1: v1(70.688,39.085) 70.688,39.751 70.928,39.991 70.928,41.286 71.034,41.392 71.034,48.631 72.137,49.734 72.137,51.764 71.875,52.026 v1(71.875,52.525)
  Signal Layer 4 w0.1: v1(71.875,52.525) 71.967,52.525 72.138,52.355 76.485,52.355 77.138,51.702 77.378,51.46 77.876,51.46 78.609,52.193 v1(79.85,52.193)
  Bottom Layer w0.1: TPJ811.1@77.9,52.7 79.343,52.7 v1(79.85,52.193)
DH_TCK_SWCLK: D800.1 P800.4 TPJ818.1 U800.9 | length 26
  Top Layer w0.1: v1(72.119,41.69) 73.628,43.2 U800.9@75.025,43.2 75.132,43.307 v1(75.971,43.307) ; v1(82.725,52.15) 82.215,52.15 D800.1@82.15,52.215 82.15,52.425 82.945,53.22 P800.4@82.945,54.05
  Signal Layer 3 w0.1: v1(75.971,43.307) 75.026,44.252 75.026,49.031 74.311,49.746 74.311,50.66 75.597,51.946 v1(77.448,51.946)
  Signal Layer 4 w0.1: v1(77.448,51.946) 77.544,51.946 78.549,52.951 81.823,52.951 82.624,52.15 v1(82.725,52.15)
  Bottom Layer w0.5: TPJ818.1@71.55,40.95 71.55,41.085 72.117,41.652 72.117,41.689 v1(72.119,41.69)
DH_TDI: D800.3 P800.8 TPJ820.1 U802.2 | length 28.2
  Top Layer w0.1: U802.2@69.175,39.8 70.153,39.8 70.529,40.176 70.529,40.524 v1(70.535,40.53) ; P800.8@80.405,54.05 80.405,53.17 81.15,52.425 D800.3@81.15,52.215 v1@81.15,50.494
  Signal Layer 3 w0.1: v1(70.535,40.53) 70.529,40.537 70.529,41.169 70.834,41.474 70.834,48.939 71.744,49.849 v1(71.744,51.297)
  Signal Layer 4 w0.1: v1(71.744,51.297) 71.822,51.375 72.025,51.375 72.354,51.704 74.066,51.704 74.401,51.369 75.793,51.369 76.302,50.86 80.783,50.86 v1(81.153,50.491)
  Bottom Layer w0.1: TPJ820.1@80.2,50.95 80.298,50.852 80.791,50.852 80.817,50.827 v1(81.153,50.491)
DH_TDO_SWO: D800.2 P800.6 TPJ812.1 U800.10 | length 25.1
  Top Layer w0.1: v1(74.052,43.928) 74.947,43.928 U800.10@75.025,43.85 ; P800.6@81.675,54.05 81.65,54.025 D800.2@81.65,52.215 81.65,51.074 81.837,50.887 82.091,50.887 82.356,50.622 v1(82.398,50.622)
  Signal Layer 3 w0.1: v1(74.052,43.928) 74.826,44.702 74.826,48.948 74.111,49.663 74.111,50.743 74.564,51.196 v1(74.564,51.762)
  Signal Layer 4 w0.1: v1(74.564,51.762) 75.683,51.762 76.385,51.06 81.689,51.06 81.782,50.967 82.052,50.967 v1(82.398,50.622)
  Bottom Layer w0.1: TPJ812.1@81.65,53.45 81.65,51.2 81.9,50.95 82.07,50.95 v1(82.398,50.622)
DH_TMS_SWDIO: D800.7 P800.2 TPJ814.1 U800.3 | length 31.1
  Top Layer w0.1: v1(68.189,45.139) 69.164,45.139 U800.3@69.175,45.15 ; v1(82.702,51.232) 81.945,51.232 81.9,51.277 81.9,51.525 82.075,51.7 83.025,51.7 83.675,52.35 83.675,52.675 84.215,53.215 P800.2@84.215,54.05 84.215,55.665 v1(84.225,55.675)
  Signal Layer 3 w0.1: v1(68.189,45.139) 67.84,45.139 67.555,45.425 67.555,46.701 67.92,47.066 70.116,47.066 70.587,47.537 70.587,49.2 71.247,49.86 v1(71.247,51.892)
  Signal Layer 4 w0.1: v1(71.247,51.892) 71.357,51.892 71.577,52.112 73.965,52.112 74.008,52.155 76.402,52.155 76.938,51.619 ; 76.938,51.618 77.295,51.26 82.674,51.26 v1(82.702,51.232)
  Bottom Layer w0.1: v1(84.225,55.675) 84.225,54.425 TPJ814.1@84.35,54.3
DH_VTREF: D809.1 P800.1 Q800.3 | length 40.1
  Top Layer w0.3: v1(65.989,37.033) 66.029,37.073 66.029,37.373 Q800.3@66.033,37.377 ; P800.1@84.215,57.95 84.215,57.035 84.95,56.3 D809.1@84.95,52.2 ; D809.1@84.95,52.1 85,52.05 v1(85,50.8)
  Signal Layer 3 w0.3: v1(65.689,39.907) 65.689,37.39 65.989,37.089 v1(65.989,37.033) ; v1(84.277,41.839) 83.642,42.474 83.642,48.819 85,50.177 v1(85,50.8)
  Signal Layer 4 w0.3: v1(65.689,39.907) v1@65.785,39.907 ; v1@65.785,39.906 66.625,39.906 66.836,40.117 67.717,40.117 67.942,39.892 73.7,39.892 74.874,41.066 79.198,41.066 79.261,41.13 79.261,41.134 79.873,41.746 83.46,41.746 83.553,41.839 v1(84.277,41.839)
EXP_HEADER11: P101.11