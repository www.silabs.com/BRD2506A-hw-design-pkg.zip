# Altium PCB PCB2506A_A02.PcbDoc (part 7 of 7)
Units mm, origin at the board's own origin, x right, y up, seen from the top; angles counter-clockwise.
Board outline 115 x 60 mm, 6 copper layers (Top Layer, Signal Layer 2, Signal Layer 3, Signal Layer 4, Signal Layer 5, Bottom Layer), stack 1.555 mm thick; 377 components, 291 nets, 1299 pads, 899 vias.

## Silkscreen, mask and mechanical layers (free items; w line width, h text height) (continued)
Bottom Component Center:
  lines w0.1: 0,1.2 ccw(c1.2,1.2) 1.2,0 113.8,0 ccw(c113.8,1.2) 115,1.2 115,58.8 ccw(c113.8,58.8) 113.8,60 1.2,60 ccw(c1.2,58.8) 0,58.8 0,1.2 ; 108.7,46.9 ccw(c109.1,46.9) 109.1,46.5 113.8,46.5 ccw(c113.8,46.9) 114.2,46.9 114.2,48.9 ccw(c113.8,48.9) 113.8,49.3 ccw(c113.8,48.9) 113.4,48.9 113.4,47.3 109.5,47.3 109.5,48.9 ccw(c109.1,48.9) 109.1,49.3 ccw(c109.1,48.9) 108.7,48.9 108.7,46.9 ; 108.7,51.5 ccw(c109.1,51.5) 109.1,51.1 ccw(c109.1,51.5) 109.5,51.5 109.5,53.1 113.4,53.1 113.4,51.5 ccw(c113.8,51.5) 113.8,51.1 ccw(c113.8,51.5) 114.2,51.5 114.2,53.5 ccw(c113.8,53.5) 113.8,53.9 109.1,53.9 ccw(c109.1,53.5) 108.7,53.5 108.7,51.5
Assembly Drawing Frame (Top):
  lines w0.2: -75.055,-40.875 -73.43,-40.875 ; -75.055,5.8 -73.43,5.8 ; -75.055,52.475 -73.43,52.475 ; -20.406,-89.125 -20.406,-87.525 ; -20.406,99.175 -20.406,100.775 ; 32.619,-89.125 32.619,-87.525 ; 32.619,99.175 32.619,100.775 ; 85.644,-89.125 85.644,-87.525 ; 85.644,99.175 85.644,100.775 ; 138.67,-89.125 138.67,-87.525 ; 138.67,99.175 138.67,100.775 ; 191.695,-40.85 193.32,-40.85 ; 191.695,5.825 193.32,5.825 ; 191.695,52.5 193.32,52.5 ; 193.32,-89.125 -75.055,-89.125 -75.055,100.775 193.32,100.775 193.32,-89.1 ; -73.43,-87.525 191.695,-87.525 191.695,99.175 -73.43,99.175 -73.43,-87.525
  text "5" at -48.083,99.804 h0.5
  text "1" at 167.624,99.794 h0.5
  text "2" at 111.801,99.79 h0.5
  text "4" at 5.582,99.694 h0.5
  text "3" at 60.57,99.694 h0.5
  text "D" at 192.41,75.734 h0.5
  text "D" at -74.402,75.614 h0.5
  text "C" at 192.318,29.368 h0.5
  text "C" at -74.474,29.3 h0.5
  text "B" at 192.502,-17.274 h0.5
  text "B" at -74.314,-18.048 h0.5
  text "A" at 192.41,-62.919 h0.5
  text "A" at -74.43,-63.952 h0.5
  text "3" at 60.964,-88.516 h0.5
  text "4" at 8.082,-88.543 h0.5
  text "2" at 112.8,-88.541 h0.5
  text "1" at 167.702,-88.59 h0.5
  text "5" at -48.128,-88.62 h0.5
Title Block (Top):
  drawing of 27 lines, arcs and shapes, not listed
  text "Board Title" at 122.095,-62.575 h2.5
  text "EFM32 PG28 Pro Kit" at 123.495,-68.125 h3.5
  text "Page Title" at 122.095,-72.3 h2.5
  text "Designed:" at 89.845,-76.05 h1.7
  text "Approved:" at 106.044,-76.05 h1.7
  text "Top Assembly" at 123.495,-76.2 h3.2
  text "YVB" at 91.369,-78.55 h2.2
  text "DDC" at 107.42,-78.55 h2.2
  text "Revision" at 179.995,-79.325 h1.7
  text "Document number" at 122.095,-79.6 h2.35
  text "Size" at 89.845,-80.8 h1.7
  text "Sheet Modified Date" at 94.77,-80.8 h1.7
  text "A02" at 180.269,-82.375 h2.7
  text "BRD2506A (PCB2506A Rev A02)" at 123.495,-82.475 h3.2
  text "A4" at 90.419,-82.65 h2
  text "'.Print_Date'" at 95.344,-82.65 h2
  text "Sheet" at 179.995,-85 h1.7
  text "COPYRIGHT SILICON LABORATORIES  INC. 2022" at 94.492,-86.008 h1.7
  text "CONFIDENTIAL -SUBJECT TO TERMS OF USE" at 134.474,-86.008 h1.7
  text "1" at 181.194,-86.95 h1.7
  text "of" at 184.319,-86.95 h1.7
  text "2" at 187.045,-86.95 h1.7
Assembly Drawing Frame (Bottom):
  lines w0.2: -75.055,-40.875 -73.43,-40.875 ; -75.055,5.8 -73.43,5.8 ; -75.055,52.475 -73.43,52.475 ; -20.406,-89.125 -20.406,-87.525 ; -20.406,99.175 -20.406,100.775 ; 32.619,-89.125 32.619,-87.525 ; 32.619,99.175 32.619,100.775 ; 85.644,-89.125 85.644,-87.525 ; 85.644,99.175 85.644,100.775 ; 138.67,-89.125 138.67,-87.525 ; 138.67,99.175 138.67,100.775 ; 191.695,-40.85 193.32,-40.85 ; 191.695,5.825 193.32,5.825 ; 191.695,52.5 193.32,52.5 ; 193.32,-89.125 -75.055,-89.125 -75.055,100.775 193.32,100.775 193.32,-89.1 ; -73.43,-87.525 191.695,-87.525 191.695,99.175 -73.43,99.175 -73.43,-87.525
  text "5" at -47.684,99.864 h0.5
  text "2" at 112.147,99.804 h0.5
  text "1" at 167.78,99.798 h0.5
  text "4" at 5.948,99.733 h0.5
  text "3" at 60.92,99.702 h0.5
  text "D" at 192.703,75.77 h0.5
  text "D" at -74.06,75.574 h0.5
  text "D" at -74.06,75.574 h0.5
  text "C" at -74.166,29.365 h0.5
  text "C" at 192.643,29.363 h0.5
  text "B" at 192.797,-17.265 h0.5
  text "B" at -74.022,-18.016 h0.5
  text "A" at 192.718,-62.912 h0.5
  text "A" at -74.095,-63.932 h0.5
  text "3" at 61.301,-88.491 h0.5
  text "4" at 8.384,-88.563 h0.5
  text "2" at 113.157,-88.549 h0.5
  text "1" at 167.888,-88.576 h0.5
  text "5" at -47.776,-88.625 h0.5
Title Block (Bottom):
  drawing of 27 lines, arcs and shapes, not listed
  text "Board Title" at -3.83,-62.575 h2.5
  text "EFM32 PG28 Pro Kit" at -5.23,-68.125 h3.5
  text "Page Title" at -3.83,-72.3 h2.5
  text "Approved:" at 12.22,-76.05 h1.7
  text "Designed:" at 28.42,-76.05 h1.7
  text "Bottom Assembly" at -5.23,-76.2 h3.2
  text "DDC" at 10.845,-78.55 h2.2
  text "YVB" at 26.895,-78.55 h2.2
  text "Revision" at -61.73,-79.325 h1.7
  text "Document number" at -3.83,-79.6 h2.35
  text "Sheet Modified Date" at 23.495,-80.8 h1.7
  text "Size" at 28.42,-80.8 h1.7
  text "A02" at -61.995,-82.375 h2.7
  text "BRD2506A (PCB2506A Rev A02)" at -5.23,-82.475 h3.2
  text "'.Print_Date'" at 22.92,-82.65 h2
  text "A4" at 27.845,-82.65 h2
  text "Sheet" at -61.73,-85 h1.7
  text "COPYRIGHT SILICON LABORATORIES  INC. 2022" at 23.658,-85.936 h1.7
  text "CONFIDENTIAL -SUBJECT TO TERMS OF USE" at -16.906,-86.024 h1.7
  text "2" at -68.78,-86.95 h1.7
  text "of" at -66.055,-86.95 h1.7
  text "2" at -62.93,-86.95 h1.7
Assembly Drawing Frame:
  lines w0.2: -82.618,-94.272 -82.618,106.203 200.882,106.203 200.882,-94.272 -82.618,-94.272